options:
  parameters:
    author: VTEM Labs
    description: 'CTF 1 (GUI): 2-FSK demod of pass_ctf.iq to bits, tags the CCSDS sync word 0x1ACFFC1D'
    generate_options: qt_gui
    id: ctf1_sync
    output_language: python
    run_options: run
    title: CTF 1 sync word finder
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: from pass_ctf.json
    value: '48000'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: samples per symbol (48000 / 2400 baud)
    value: '20'
  states: {}
- name: dev
  id: variable
  parameters:
    comment: FSK deviation in Hz (Q5; only scales the demod output)
    value: '4500'
  states: {}
- name: imports_0
  id: import
  parameters:
    imports: import os, glob
  states: {}
- name: in_file
  id: variable
  parameters:
    comment: 'finds pass_ctf.iq: next to the .grc, else anywhere under your home folder. Set a full path here to override.'
    value: next(iter([p for p in [os.path.join(os.getcwd(), "pass_ctf.iq")] if os.path.isfile(p)] + sorted(glob.glob(os.path.expanduser("~/**/pass_ctf.iq"), recursive=True))), "pass_ctf.iq")
  states: {}
- name: bits_file
  id: variable
  parameters:
    comment: one byte per bit (00/01), written next to pass_ctf.iq
    value: os.path.join(os.path.dirname(os.path.abspath(in_file)), "bits.bin")
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: in_file
    repeat: 'False'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: instantaneous frequency, about +1 for a 1 and -1 for a 0
    gain: samp_rate/(2*math.pi*dev)
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    comment: average over one symbol (matched filter for FSK)
    length: sps
    max_iter: '4000'
    scale: 1.0/sps
    type: float
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    comment: one sample per symbol, at the end of each averaging window
    n: sps
    type: float
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters:
    comment: '> 0 is 1, otherwise 0'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: bits_file
    type: byte
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '"00011010110011111111110000011101"'
    comment: 0x1ACFFC1D (CCSDS ASM); tag lands on the first bit AFTER the sync word
    tagname: '"sync"'
    threshold: '0'
    type: byte
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    filter: '"sync"'
    name: '"ASM found"'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle2
  parameters:
    comment: plays the file at real speed (1.5 s) so the plots are watchable
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters:
    comment: bits as 0.0 / 1.0 for plotting
  states: {}
- name: qtgui_time_sink_demod
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    legend: 'False'
    name: '"Demod, averaged per symbol (above 0 = 1, below 0 = 0)"'
    size: '480'
    srate: samp_rate
    type: float
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_bits
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    legend: 'False'
    name: '"Bits - display freezes on each sync tag (frame start)"'
    size: '96'
    srate: samp_rate/sps
    type: float
    ymax: '1.2'
    ymin: '-0.2'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"sync"'
    tr_delay: 32/(samp_rate/sps)
    tr_level: '0.5'
  states: {}
- name: snippet_window_size
  id: snippet
  parameters:
    comment: opens the window big enough to read both plots
    code: self.resize(1200, 900)
    section: main_after_init
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_time_sink_demod, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_bits, '0']
- [analog_quadrature_demod_cf_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_keep_one_in_n_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_file_sink_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_tag_debug_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
